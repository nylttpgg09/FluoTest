# Keil uVision project 0-Option_detect_mobile.uvprojx, settings and files
target 0-Option_detect_mobile (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: 0-Option_detect_mobile +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;..\Core\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c 41100.c em1365.c OD_CircularQueue.c OD_SimulateUart.c SEGGER_RTT.c SEGGER_RTT_printf.c i2c.c motor.c rx8025.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
software components: CMSIS:CORE 4.3.0
